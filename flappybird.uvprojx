# Keil uVision project flappybird.uvprojx, settings and files
target flappybird (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: flappybird +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: .\core;.\devices;.\app;.\boot;.\app\RES\Num;.\app\RES\Pic
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: .\obj\flappybird.sct
  group app
    ./app/: main.c game.c Font_Num.c
  group boot
    ./boot/: startup_stm32f10x_hd.s
  group core
    ./core/: jpstm32_delay.c jpstm32_gpio.c jpstm32_nvic.c jpstm32_sysclk.c jpstm32_usart.c
  group devices
    ./devices/: jpstm32_lcd.c fsmc.c dma.c led.c touch.c timer.c adc.c jpstm32_key.c iic.c 24cxx.c jpstm32_beep.c
