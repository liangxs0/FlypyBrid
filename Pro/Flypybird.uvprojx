# Keil uVision project Flypybird.uvprojx, settings and files
target FlypyBird (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Flypybird +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c include: ..\boot\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\boot\STM32F10x_StdPeriph_Driver\inc;..\boot\CMSIS\CM3\CoreSupport;..\app\inc;..\devices\inc;..\hardware\inc
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group app
    ../app/src/: main.c game.c draw_bird.c
    ../app/inc/: common.h stm32f10x_conf.h game.h draw_bird.h
  group boot
    ../boot/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_hd.s
  group CMSIS
    ../boot/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
    ../boot/CMSIS/CM3/CoreSupport/: core_cm3.c
  group Image
    ../Image/: board0.c borid_down.c borid_move.c borid_up.c floor_map.c game_voer.c logo.c ready.c start.c
  group devices
    ../devices/src/: briupBasePeriph.c briupDelay.c briupEXSRAM.c briupFSMC.c briupIWDG.c briupKeyboard.c briupLCD.c briupMPU6050.c briupMPUDriver.c briupNVIC.c briupRTC.c briupSDIO.c briupSPI.c briupTIM2.c briupTouch.c briupUsart.c briupVS1003.c inv_mpu.c
